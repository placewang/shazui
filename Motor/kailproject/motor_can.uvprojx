# Keil uVision project motor_can.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MM32SPIN06PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: motor_can +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\MM32SPIN06xx_s\Include;..\MM32SPIN06xx_s\HAL_Lib\Inc;..\USER\In
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ../MM32SPIN06xx_s/Source/: system_mm32spin06xx_s.c
    ../MM32SPIN06xx_s/Source/KEIL_StartAsm/: startup_mm32spin06xx_s_keil.s
  group Lib
    ../MM32SPIN06xx_s/HAL_Lib/Src/: hal_gpio.c hal_rcc.c hal_uart.c hal_misc.c hal_tim.c hal_spi.c hal_can.c
  group user
    ../USER/: delay.c uart.c GPIO.c tim3_pwm_input.c spi.c can.c MotorCan.c MotorMove.c
  group main
    ../USER/: main.c
